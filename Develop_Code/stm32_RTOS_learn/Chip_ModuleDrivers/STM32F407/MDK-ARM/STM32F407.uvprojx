# Keil uVision project STM32F407.uvprojx, settings and files
target STM32F407 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F407 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/keyExti_Device;../Drivers/BSP/LED_Device;../../../SmartDevice/Chip_Abstraction_Layer/key;../../../SmartDevice/Chip_Abstraction_Layer/led;../../../SmartDevice/Chip_Abstraction_Layer/time;../../../SmartDevice/Chip_Abstraction_Layer/oled;../../../SmartDevice/Kernel_Abstraction_Layer/key;../../../SmartDevice/Kernel_Abstraction_Layer/led;../../../SmartDevice/Kernel_Abstraction_Layer/time;../../../SmartDevice/Kernel_Abstraction_Layer/oled;../../../SmartDevice/Sub_System/Device_system;../../../SmartDevice/Sub_System/Display_system;../../../SmartDevice/Sub_System/Input_system;../../../SmartDevice/Test_System;../../../System_Config;../Drivers/BSP/OLED/oled_SPI/hardware;../Drivers/BSP/debug_com;..\Drivers\BSP\OLED
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group System_Config
    ../../../System_Config/: System_Config.h
    ../ST_Config/: ST_Config.h
  group Chip_ModuleDrivers/STM32F407/Drivers/BSP
    ../Drivers/BSP/keyExti_Device/: keyExti.c
    ../Drivers/BSP/LED_Device/: LED.c
    ../Drivers/BSP/OLED/: oled_ssd1306.c
    ../Drivers/BSP/debug_com/: debug_com.c
    ../Drivers/BSP/OLED/oled_SPI/hardware/: oled_hardware_SPI.c
  group SmartDevice/Chip_Abstraction_Layer
    ../../../SmartDevice/Chip_Abstraction_Layer/key/: cal_gpio_key.c
    ../../../SmartDevice/Chip_Abstraction_Layer/led/: cal_led.c
    ../../../SmartDevice/Chip_Abstraction_Layer/time/: cal_time.c
    ../../../SmartDevice/Chip_Abstraction_Layer/oled/: cal_oled.c
  group SmartDevice/Kernel_Abstraction_Layer
    ../../../SmartDevice/Kernel_Abstraction_Layer/key/: kal_gpio_key.c
    ../../../SmartDevice/Kernel_Abstraction_Layer/led/: kal_led.c
    ../../../SmartDevice/Kernel_Abstraction_Layer/time/: kal_time.c
    ../../../SmartDevice/Kernel_Abstraction_Layer/oled/: kal_oled.c
  group SmartDevice/Sub_System
    ../../../SmartDevice/Sub_System/Device_system/: led_device.c
    ../../../SmartDevice/Sub_System/Display_system/: display_device.c oled_device.c display_system.c
    ../../../SmartDevice/Sub_System/Input_system/: gpio_key.c input_buffer.c input_system.c
  group SmartDevice/Test_System
    ../../../SmartDevice/Test_System/: device_led_test.c input_test.c device_oled_test.c
target SmartDevice (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: as above
  output: STM32F407 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
software components: CMSIS:CORE 4.3.0
